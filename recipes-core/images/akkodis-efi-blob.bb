LICENSE = "MIT"

INITRD_IMAGE = "akkodis-image-initramfs"

inherit efi-blob