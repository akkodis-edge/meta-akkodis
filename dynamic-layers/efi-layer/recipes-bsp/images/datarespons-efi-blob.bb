LICENSE = "MIT"

INITRD_IMAGE = "datarespons-image-initramfs"

inherit efi-blob